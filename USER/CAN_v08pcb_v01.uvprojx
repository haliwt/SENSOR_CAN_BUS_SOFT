# Keil uVision project CAN_v08pcb_v01.uvprojx, settings and files
target CAN (ARM-ADS)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CAN3_10 +hex
  c flags: Optim=1
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\CAN;..\HARDWARE\CAN2;..\HARDWARE\SENSOR;..\HARDWARE\IIC(24C02);..\HARDWARE\AT24Cxx;..\HARDWARE\rs232
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/CAN2/: can2.c
    ../HARDWARE/SENSOR/: sensor.c
    ../HARDWARE/IIC(24C02)/: iic.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/rs232/: rs232.c
    ../HARDWARE/AT24Cxx/: AT24CXX.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_can.c stm32f10x_usart.c
  group README
    ../: README.TXT
